# Keil uVision project whim.uvprojx, settings and files
target nrf52832_xxaa (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: ANT_STACK_SUPPORT_REQD BOARD_D52DK1 FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 S212 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\ant\ant_channel_config;..\..\components\ant\ant_search_config;..\..\components\boards;..\..\components\drivers_nrf\common;..\..\components\drivers_nrf\delay;..\..\components\drivers_nrf\gpiote;..\..\components\drivers_nrf\hal;..\..\components\drivers_nrf\spi_master;..\..\components\drivers_nrf\uart;..\..\components\libraries\atomic;..\..\components\libraries\balloc;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\experimental_log;..\..\components\libraries\experimental_log\src;..\..\components\libraries\experimental_memobj;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\hardfault;..\..\components\libraries\hardfault\nrf52;..\..\components\libraries\fstorage;..\..\components\libraries\mutex;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\scheduler;..\..\components\libraries\strerror;..\..\components\libraries\timer;..\..\components\libraries\util;..\..\components\libraries\atomic_fifo;..\..\components\softdevice\common;..\..\components\softdevice\s212\headers;..\..\components\softdevice\s212\headers\nrf52;..\..\components\toolchain;..\..\..;..\..\external\fprintf;..\..\external\segger_rtt;..\project;..\..\components\libraries\queue
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DSWI_DISABLE0
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x12000 size 0x6d000
  memory RVCT9: RAM 0x20000b80 size 0xf480
  memory RVCT10: RAM 0x800000 size 0x10000
  link misc: --diag_suppress 6330
  group Accel
    ./: ADXL375.c ADXL375.h ADXL375_registers.h
  group Ant
    ./: ANT.c ANT.h
  group Application
    ../: main.c
    ../config/: sdk_config.h
  group Algo
    ./: algo.c algo.h
  group Board Definition
    ../../components/boards/: boards.c
  group Board Support
    ../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group nRF_ANT
    ../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../components/ant/ant_search_config/: ant_search_config.c
  group nRF_Drivers
    ../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/timer/: app_timer.c
    ../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c nrf_sdh_soc.c
  group flash_fstorage
    ./: fstorage_manager.c fstorage_manager.h
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
